# Keil uVision project AD7076progrm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AD7076progrm +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AD7076.h AD7076.c main.c other.h other.c
